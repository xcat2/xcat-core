# libspdm has no s390x architecture mapping.
COMPATIBLE_HOST:s390x = "null"
