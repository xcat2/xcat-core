COMPATIBLE_HOST:s390x = "s390x.*-linux"
